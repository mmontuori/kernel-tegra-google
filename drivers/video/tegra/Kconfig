## drivers/video/tegra/Kconfig
```kconfig
config TEGRA_DC
	tristate "Tegra Display Contoller"
	depends on ARCH_TEGRA
	help
	  Tegra display controller support.
```
